# Keil uVision project VibraNode.uvprojx, settings and files
target VibraNode (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F413CCU7 ArteryTek
  pack: ArteryTek.AT32F413_DFP.2.1.8
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x3F000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: VibraNode +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F413CCU7, USE_STDPERIPH_DRIVER
  c misc: --wchar32
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\middlewares\sensors;..\..\middlewares\sensors\adxl357;..\..\middlewares\sensors\icm42688;..\..\middlewares\usbd_drivers\inc;..\..\middlewares\usbd_class\cdc;..\..\middlewares\SEGGER_RTT_V798g\RTT;..\..\middlewares\SEGGER_RTT_V798g\Config;..\..\middlewares\agm\include
  memory RVCT4: ROM 0x8000000 size 0x3f000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: ..\..\middlewares\agm\lib\libInvnAlgoAGM.a
  group Sensor components
    ../src/: probe_board_check.c probe_eopb0.c probe_stack.c probe_acquisition.c probe_capture_check.c
    ../../middlewares/sensors/adxl357/: adxl357.c
    ../../middlewares/sensors/icm42688/: icm42688.c
  group USB link
    ../src/: probe_frame.c probe_usb.c probe_proto.c probe_led.c probe_attitude.c probe_calib.c
  group USB device
    ../../middlewares/usbd_drivers/src/: usbd_core.c usbd_int.c usbd_sdr.c
    ../../middlewares/usbd_class/cdc/: cdc_class.c cdc_desc.c
  group user
    ../src/: probe_spi.c probe_validation.c probe_time.c probe_dma.c main.c at32f413_wk_config.c at32f413_int.c rtc.c wk_system.c
  group SEGGER RTT
    ../../middlewares/SEGGER_RTT_V798g/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group firmware
    ../../libraries/drivers/src/: at32f413_crm.c at32f413_tmr.c at32f413_rtc.c at32f413_gpio.c at32f413_i2c.c at32f413_usart.c at32f413_pwc.c at32f413_adc.c at32f413_spi.c at32f413_dma.c at32f413_flash.c at32f413_crc.c at32f413_wwdt.c at32f413_wdt.c at32f413_exint.c at32f413_misc.c at32f413_usb.c at32f413_acc.c at32f413_can.c at32f413_sdio.c at32f413_debug.c at32f413_bpr.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32f413.c
    ./: startup_at32f413.s
